## config/boards/shields/minideck/Kconfig.defconfig
```kconfig
if SHIELD_MINIDECK

config ZMK_KEYBOARD_NAME
    default "minideck"

config BT_DEVICE_NAME
    default ZMK_KEYBOARD_NAME

endif
```
